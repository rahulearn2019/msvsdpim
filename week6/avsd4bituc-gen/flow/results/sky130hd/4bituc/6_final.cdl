$ CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT async4bituc VDD VSS out vref

$ CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT imc GND Q1 Q2 RBLprecharge RBLprechargeEnable RWL
+ SEL VDD WBL1 WBL2 WBLB1 WBLB2 WWL out VSS
X_0_ mux.in1 mux.in2 SEL VSS VSS VDD VDD out sky130_fd_sc_hd__mux2_4
